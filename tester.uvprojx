# Keil uVision project tester.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F417IETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: tester +hex
  c flags: Optim=2 oTime=1
  c define: STM32F417xx,ColorDepthBpp16, tftili9486, SOFTWARE_GL,GUI_ALLIGN_LAYSIZE_TO_POW2,
  c misc: --cpp
  c include: .\device\GUI\inc;.\device\hardware\inc;.\device\init\inc;.\misc\inc;.\user\inc;..\tester_1.03;.\memory\inc;.\drivers\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT6: RAM 0x60000000 size 0xeffff
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\tester.sct
  group user
    ./user/src/: main.cpp
  group drivers
    ./drivers/src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
  group init
    ./device/init/src/: init.cpp
  group GUI
    ./device/GUI/src/: Screen.cpp Terminal_interface.cpp
  group device
    ./device/hardware/src/: gpio_ex.cpp TFTili9486.cpp device.cpp
    ./user/src/: stm32f4xx_it.c
    ./: extern.cpp
  group misc
    ./misc/src/: geometry.cpp locker.cpp affine_tf.cpp physic.cpp
    ./device/GUI/src/: dtostr.cpp
  group memory
    ./memory/src/: memory_alloc.cpp
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 2.1.0
